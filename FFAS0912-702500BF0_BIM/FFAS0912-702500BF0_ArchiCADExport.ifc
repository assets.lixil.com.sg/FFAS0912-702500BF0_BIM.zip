Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-31T00:03:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 31 00:03:49 2023 * Host: DESKTOP-D2DSTPK * Database: C:\Users\WINDOWS\AppData\Local\Temp\3e457ab1-953c-47fd-b30b-2f2c4a99cde3\a64aba00-429d-4763-90e6-ad9548365c7a\ifc * Database version: 5507 * Database creation date: Fri Mar 31 00:03:48 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 31 00:03:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 31 00:03:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (3)
Description: Flow
Name | FlowDirection
2 x Port_347220 | SOURCE
Port_347220 | SINK

# IfcFlowTerminal: FFAS0912-7T2501BT0_REVIT:Milano Exposed Shower Mixer W/o Shower K, FFAS0912-7T2501BT0_REVIT:Milano Exposed Shower Mixer W/o Shower K:347220
In: Level 1
Material: Brass
Pset_DistributionFlowElementCommon - Reference: Milano Exposed Shower Mixer W/o Shower K; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
